# Keil uVision project OLED12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5608AD STC-STC12
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(45000000)
  output: OLED12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 OLED12864.c
